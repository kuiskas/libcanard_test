# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX; HSE_VALUE=8000000
  ICCARM.CCIncludePath2: C:\Users\Martins\Documents\IAR Embedded Workbench\arm\8.30.1\ST\STM32F4xx\STM32F4xx_DSP_StdPeriph_Lib\Project\first_project; C:\Users\Martins\Desktop\STM32F4-Discovery_FW_V1.1.0\Libraries\CMSIS\Include; C:\Users\Martins\Desktop\STM32F4-Discovery_FW_V1.1.0\Libraries\CMSIS\ST\STM32F4xx\Include; $PROJ_DIR$; C:\Users\Martins\Desktop\STM32F4-Discovery_FW_V1.1.0\Libraries\STM32F4xx_StdPeriph_Driver\inc; C:\Users\Martins\Documents\IAR Embedded Workbench\arm\8.30.1\ST\STM32F4xx\STM32F4xx_DSP_StdPeriph_Lib\Libraries\libcanard-master; C:\Users\Martins\Documents\IAR Embedded Workbench\arm\8.30.1\ST\STM32F4xx\STM32F4xx_DSP_StdPeriph_Lib\Libraries\libcanard-master\drivers\stm32
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: project.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group EWARM
    ../../../../../../../../../Desktop/STM32F4-Discovery_FW_V1.1.0/Libraries/CMSIS/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f4xx.s
  group libcanard
    ../../Libraries/libcanard-master/: canard.c
  group libcanard/drivers
    ../../Libraries/libcanard-master/drivers/stm32/: canard_stm32.c
  group STM32F4-Discovery
    ../../../../../../../../../Desktop/STM32F4-Discovery_FW_V1.1.0/Utilities/STM32F4-Discovery/: stm32f4_discovery.c
  group STM32F4xx_StdPeriph_Dirver
    ../../../../../../../../../Desktop/STM32F4-Discovery_FW_V1.1.0/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group User
    ./: main.c
    ../../../../../../../../../Desktop/Useful_Files_STM32F4/: stm32f4xx_it.c
    ../../../../../../../../../Desktop/STM32F4-Discovery_FW_V1.1.0/Libraries/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
